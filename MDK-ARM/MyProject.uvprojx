# Keil uVision project MyProject.uvprojx, settings and files
target Debug (6240000::V6.24::ARMCLANG)
  device: CIU32F003F5Px HED
  pack: HED.CIU32F003_DFP.1.0.0
  cpu: IROM(0x00000000,0x00006000) IRAM(0x20000000,0x00000C00) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: MyProject +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG USE_FULL_ASSERT USE_STDPERIPH_DRIVER
  c include: ..\Vendor_Library\CIU32F003_Lib\Include;..\Vendor_Library\CMSIS\Device;..\Vendor_Library\CMSIS\Core;..\Vendor_Library\CIU32F003_Lib\Source;..\Project_Source\Application;..\Project_Source\Core;..\Project_Source\Drivers
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x6000
  memory RVCT9: RAM 0x20000000 size 0xc00
  scatter file: .\Objects\Debug\MyProject.sct
  group Vendor_Library/CIU32F003_LIB
    ../Vendor_Library/CIU32F003_Lib/Source/: ciu32f003_std.c ciu32f003_std_adc.c ciu32f003_std_comp.c ciu32f003_std_crc.c ciu32f003_std_exti.c ciu32f003_std_flash.c ciu32f003_std_gpio.c ciu32f003_std_i2c.c ciu32f003_std_lptim.c ciu32f003_std_pmu.c ciu32f003_std_rcc.c ciu32f003_std_spi.c ciu32f003_std_tim.c ciu32f003_std_uart.c
  group Vendor_Library/CMSIS
    ../Vendor_Library/CMSIS/Device/: system_ciu32f003.c
  group Startup
    ../Vendor_Library/CMSIS/Device/Startup/arm/: startup_ciu32f003.s
  group Application
    ../Project_Source/Application/: app_config_repo.c
  group Core
    ../Project_Source/Core/: main.c
  group Drivers
    ../Project_Source/Drivers/: drv_clock.c drv_flash.c drv_led.c lib_flash_jpa.c
